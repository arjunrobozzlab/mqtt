# Keil uVision project SHRTIM_CBC_Deadtime.uvprojx, settings and files
target N32H474 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: N32H474VE Nationstech
  pack: Nationstech.N32H47x_DFP.0.8.0
  cpu: IRAM(0x20000000,0x31000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: SHRTIM_CBC_Deadtime
  AfterMake: fromelf --bin --output=.\bin\SHRTIM_CBC_Deadtime.bin .\Objects\SHRTIM_CBC_Deadtime.axf
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: N32H474, USE_STDPERIPH_DRIVER, ENTRY_TEST
  c include: ..\inc;..\..\..\..\..\..\firmware\CMSIS\core;..\..\..\..\..\..\firmware\CMSIS\device;..\..\..\..\..\..\firmware\n32h47x_48x_std_periph_driver\inc;..\..\..\..\bsp\inc;..\test
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x31000
  group STARTUP
    ../../../../../../firmware/CMSIS/device/startup/: startup_n32h474.s
  group CMSIS
    ../../../../../../firmware/CMSIS/device/: system_n32h47x_48x.c
  group FWLB
    ../../../../../../firmware/n32h47x_48x_std_periph_driver/src/: n32h47x_48x_rcc.c n32h47x_48x_shrtim.c n32h47x_48x_pwr.c n32h47x_48x_gpio.c misc.c n32h47x_48x_flash.c
  group USER
    ../src/: main.c n32h47x_48x_it.c n32h47x_48x_msp.c
  group DOC
    ../: readme.txt
  group BSP
    ../../../../bsp/src/: delay.c
  group TEST
    ../test/: test.c
